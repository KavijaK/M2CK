options:
  parameters:
    author: Kavija Karunarathna
    category: Custom
    generate_options: qt_gui
    id: comsys
    output_language: python
    title: comsysFinal
  states: {}

blocks:
- name: ack_repetitions
  id: variable_qtgui_range
  parameters:
    label: Data Repetitions
    start: '1'
    step: '100'
    stop: '2000'
    value: '5'
  states: {}
- name: cmaEqualizer
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: data_repetitions
  id: variable_qtgui_range
  parameters:
    label: Data Repetitions
    start: '1'
    step: '100'
    stop: '2000'
    value: '5'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '900000000'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '1101100111000011010101110010111011000101110010111011110010101010'
    bps: '1'
    threshold: '1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, samp_rate, samp_rate/float(sps), excess_bw, sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0005'
    freq_offset: '0.025'
    noise_voltage: '0.2'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1101100111000011010101110010111011000101110010111011110010101010'
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cmaEqualizer
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """
          Message assembler for GUI chat packets.

          Input:  byte stream (np.uint8) from ZMQ SUB Source
          Output: PDUs on 'msg_out', each PDU is a complete GUI packet:
                  [src_id][dst_id][len_hi][len_lo][payload...]

          Packet format (from GUI):
            byte 0: src_id       (uint8)
            byte 1: dst_id       (uint8)
            byte 2: len_hi       (uint8)
            byte 3: len_lo       (uint8)
            bytes 4..(4+len-1): payload bytes (UTF-8 text)
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="message_assembler",
                  in_sig=[np.uint8],
                  out_sig=None,  # no stream output; only PDUs
              )

              # Internal buffer to accumulate bytes across work() calls
              self._buf = bytearray()

              # Register output message port
              self.message_port_register_out(pmt.intern("msg_out"))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)

              if n == 0:
                  return 0

              # Append new bytes from the stream into our buffer
              self._buf.extend(in0.tobytes())

              # Try to extract as many complete packets as possible
              while True:
                  # Need at least 4 bytes for header: src, dst, len_hi, len_lo
                  if len(self._buf) < 4:
                      break

                  src_id = self._buf[0]
                  dst_id = self._buf[1]
                  length = (self._buf[2] << 8) | self._buf[3]

                  # Sanity check on length (optional, but helpful)
                  if length < 0 or length > 65535:
                      print("[message_assembler] Invalid length field:", length)
                      self._buf.clear()
                      break

                  # Do we have the full payload yet?
                  needed = 4 + length
                  if len(self._buf) < needed:
                      # Not enough data yet; wait for next work() call
                      break

                  # Extract one complete GUI packet
                  pkt_bytes = self._buf[:needed]
                  # Remove it from the buffer
                  del self._buf[:needed]

                  # Convert to a list of ints for init_u8vector
                  pkt_list = [int(b) for b in pkt_bytes]

                  # Wrap as a PDU: (dict, u8vector)
                  meta = pmt.make_dict()  # no metadata for now
                  vec = pmt.init_u8vector(len(pkt_list), pkt_list)
                  pdu = pmt.cons(meta, vec)

                  # Publish the packet
                  self.message_port_pub(pmt.intern("msg_out"), pdu)

                  # Optional debug print
                  # print(f"[message_assembler] Emitted packet: src={src_id}, dst={dst_id}, len={length}")

              # We always consume all input samples
              return n
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading

      # ARQ frame contributed by this framer (before protocol formatter + CRC)
      # RF frame: 12B header + 48B ARQ frame + 4B CRC = 64 bytes total
      ARQ_FRAME_SIZE   = 48          # bytes from this block
      ARQ_HEADER_SIZE  = 4           # [SEQ][FLAGS][SRC_ID][DST_ID]
      ARQ_PAYLOAD_SIZE = ARQ_FRAME_SIZE - ARQ_HEADER_SIZE  # 44 bytes


      class blk(gr.basic_block):
          """
          Stop-and-wait ARQ framer with fixed 48-byte frames (for 64B RF frame).

          Upstream message format (from message_assembler on 'data_in'):
              [src_id][dst_id][len_hi][len_lo][payload...]

          Framer output (on 'frame_out'): fixed 48-byte ARQ frames:
              byte 0   : SEQ        (uint8)
              byte 1   : FLAGS      (bit0 = LAST_FRAME, bit1 = IS_ACK, others 0)
              byte 2   : SRC_ID     (uint8)
              byte 3   : DST_ID     (uint8)
              byte 4.. : payload chunk (up to 44 bytes, zero-padded)

          Notes:
            - No preamble, no length, no CRC here.
              Protocol formatter (12B header) and CRC (4B) are applied later to
              reach 64B total on the air.
            - Fragmentation is done over the entire upstream message.
            - ACK frames use the same 48B format with IS_ACK=1 and empty payload.

          Retransmission behavior in this implementation:
            - For each DATA frame (one fragment):
                * Build the 48B frame once.
                * Continuously transmit that same frame on "frame_out" as a stream
                  until either:
                    - a matching ACK is received, OR
                    - the retry limit for that frame is reached.
            - retry limit per frame:
                * repeat_enable = False  -> 1 transmit (no extra retries)
                * repeat_enable = True   -> repeat_count total transmits for that frame
            - Stop-and-wait is preserved: next fragment is not started until ACK
              for the current SEQ is accepted (or you’ve exhausted retries and
              you decide what to do at a higher layer).
          """

          def __init__(self, repeat_enable=False, repeat_count=1):
              gr.basic_block.__init__(
                  self,
                  name="arq_framer",
                  in_sig=None,
                  out_sig=None,
              )

              # --- Parameters ---
              self.repeat_enable = bool(repeat_enable)
              self.repeat_count  = max(1, int(repeat_count))

              # --- ARQ state ---
              self._seq             = 0          # current SEQ (uint8)
              self._current_msg     = None       # bytes: full message from data_in
              self._msg_len         = 0
              self._offset          = 0          # how many bytes already sent from msg
              self._last_chunk_len  = 0          # last payload chunk length
              self._waiting_for_ack = False

              self._src_id          = 0
              self._dst_id          = 0

              # Keep original metadata to propagate downstream if needed
              self._current_meta    = pmt.PMT_NIL

              # Retransmission state:
              #   _current_frame_pdu : last frame we are actively trying to get ACK for
              #   _retries_left      : how many more times we'll transmit this frame
              #   _resend_interval   : small delay between transmits (behaves like stream)
              self._current_frame_pdu = None
              self._retries_left      = 0
              self._resend_interval   = 0.001  # seconds; small -> almost continuous

              # --- Message ports ---
              self.message_port_register_in(pmt.intern("data_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              self.message_port_register_out(pmt.intern("frame_out"))

              self.set_msg_handler(pmt.intern("data_in"), self.handle_data_pdu)
              self.set_msg_handler(pmt.intern("ack_in"),  self.handle_ack_pdu)

              # Background retransmission loop: keeps re-sending current frame
              self._tx_thread = threading.Thread(
                  target=self._retransmit_loop,
                  daemon=True,
              )
              self._tx_thread.start()

          # ------------------------------------------------------------------
          # Background: retransmission loop
          # ------------------------------------------------------------------
          def _retransmit_loop(self):
              """
              Continuously streams the current frame while we are waiting for ACK:
                - If _waiting_for_ack is True, _current_frame_pdu is not None,
                  and _retries_left > 0:
                    * send that PDU on frame_out
                    * decrement _retries_left
                - Stops sending when:
                    * ACK handler clears _waiting_for_ack, OR
                    * _retries_left reaches 0.
              """
              port_sym = pmt.intern("frame_out")

              while True:
                  if (
                      self._waiting_for_ack
                      and self._current_frame_pdu is not None
                      and self._retries_left > 0
                  ):
                      # Transmit the current frame again
                      print("Frame transmitted")
                      self.message_port_pub(port_sym, self._current_frame_pdu)
                      self._retries_left -= 1

                      # Very small pause to avoid completely hogging CPU,
                      # but still essentially "streaming".
                      time.sleep(self._resend_interval)

                  else:
                      # Either not waiting, or no frame, or retries exhausted.
                      # Just idle a bit.
                      time.sleep(0.001)

          # ------------------------------------------------------------------
          # DATA from upper layer (new message to send)
          # ------------------------------------------------------------------
          def handle_data_pdu(self, pdu):
              """
              Accept a new higher-layer message to be fragmented and sent.

              Input PDU: (meta, u8vector)
              Bytes: [src_id][dst_id][len_hi][len_lo][payload...]

              We fragment the entire message into ARQ frames, but also copy src_id
              and dst_id into every frame header for convenience.
              """
              if self._waiting_for_ack or self._current_msg is not None:
                  print("[arq_framer] Busy (waiting for ACK or message in progress); "
                        "ignoring new data_in PDU.")
                  return

              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)

              if not pmt.is_u8vector(vec):
                  print("[arq_framer] data_in: expected u8vector")
                  return

              msg = bytes(bytearray(pmt.u8vector_elements(vec)))
              if len(msg) == 0:
                  print("[arq_framer] data_in: empty message, ignoring")
                  return

              # Extract SRC and DST from message as produced by message_assembler
              if len(msg) >= 2:
                  self._src_id = msg[0]
                  self._dst_id = msg[1]
              else:
                  self._src_id = 0
                  self._dst_id = 0
                  print("[arq_framer] Warning: message too short to extract src/dst, "
                        "using 0/0")

              self._current_msg       = msg
              self._msg_len           = len(msg)
              self._offset            = 0
              self._last_chunk_len    = 0
              self._waiting_for_ack   = False
              self._current_meta      = meta
              self._current_frame_pdu = None
              self._retries_left      = 0

              print(f"[arq_framer] New message len={self._msg_len}, "
                    f"src={self._src_id}, dst={self._dst_id}, starting at SEQ={self._seq}")

              # Kick off first fragment; retransmit loop will handle streaming
              self._send_next_frame()

          # ------------------------------------------------------------------
          # ACK from RX side
          # ------------------------------------------------------------------
          def handle_ack_pdu(self, pdu):
              """
              Handle an incoming ACK frame.

              We assume ACK PDU payload is also a 48-byte ARQ frame:
                  [SEQ][FLAGS][SRC][DST][zeros...]

              We check:
                - IS_ACK flag
                - SEQ matches current SEQ
              """
              if not self._waiting_for_ack or self._current_msg is None:
                  print("[arq_framer] Received ACK while not waiting; ignoring")
                  return

              vec = pmt.cdr(pdu)

              if not pmt.is_u8vector(vec):
                  print("[arq_framer] ack_in: expected u8vector")
                  return

              data = bytes(bytearray(pmt.u8vector_elements(vec)))
              if len(data) < ARQ_HEADER_SIZE:
                  print("[arq_framer] ack_in: frame too short:", len(data))
                  return

              seq_ack = data[0]
              flags   = data[1]

              is_ack  = (flags >> 1) & 0x01

              if not is_ack:
                  print(f"[arq_framer] ack_in: received non-ACK frame (flags=0x{flags:02X}), ignoring")
                  return

              expected_seq = self._seq & 0xFF
              if seq_ack != expected_seq:
                  print(f"[arq_framer] ack_in: SEQ mismatch (expected={expected_seq}, "
                        f"got={seq_ack}), ignoring")
                  return

              print(f"[arq_framer] ACK received for SEQ={seq_ack}")

              # ACK matches: stop retransmissions for this frame
              self._waiting_for_ack   = False
              self._current_frame_pdu = None
              self._retries_left      = 0

              # Move offset by last chunk size
              self._offset += self._last_chunk_len
              self._last_chunk_len = 0

              # Advance SEQ
              self._seq = (self._seq + 1) & 0xFF

              # Send next frame or finish message
              self._send_next_frame()

          # ------------------------------------------------------------------
          # Internal: build and prepare the next fragment (streamed by loop)
          # ------------------------------------------------------------------
          def _send_next_frame(self):
              # No active message
              if self._current_msg is None:
                  self._waiting_for_ack   = False
                  self._current_frame_pdu = None
                  self._retries_left      = 0
                  return

              # Message fully sent
              if self._offset >= self._msg_len:
                  print("[arq_framer] Message complete")
                  self._current_msg       = None
                  self._msg_len           = 0
                  self._offset            = 0
                  self._last_chunk_len    = 0
                  self._waiting_for_ack   = False
                  self._current_meta      = pmt.PMT_NIL
                  self._current_frame_pdu = None
                  self._retries_left      = 0
                  return

              # Determine next payload chunk
              remaining = self._msg_len - self._offset
              chunk_len = min(remaining, ARQ_PAYLOAD_SIZE)
              chunk     = self._current_msg[self._offset : self._offset + chunk_len]

              is_last = 1 if (self._offset + chunk_len) >= self._msg_len else 0

              last_bit = is_last & 0x01
              is_ack   = 0  # data frame
              flags    = (last_bit << 0) | (is_ack << 1)

              seq = self._seq & 0xFF

              # Build fixed-size 48-byte ARQ frame
              frame = bytearray(ARQ_FRAME_SIZE)
              frame[0] = seq
              frame[1] = flags
              frame[2] = self._src_id & 0xFF
              frame[3] = self._dst_id & 0xFF
              frame[4:4 + chunk_len] = chunk  # rest stays zero-padded

              frame_bytes = bytes(frame)

              out_meta = self._current_meta
              out_vec  = pmt.init_u8vector(len(frame_bytes), list(frame_bytes))
              out_pdu  = pmt.cons(out_meta, out_vec)

              # Store current frame for retransmissions
              self._current_frame_pdu = out_pdu

              # Total transmits for THIS frame:
              # - if repeat_enable == False -> 1 attempt
              # - if repeat_enable == True  -> repeat_count attempts
              if self.repeat_enable:
                  self._retries_left = max(1, int(self.repeat_count))
              else:
                  self._retries_left = 1

              self._last_chunk_len  = chunk_len
              self._waiting_for_ack = True

              print(f"[arq_framer] Prepared frame SEQ={seq}, chunk_len={chunk_len}, "
                    f"last={is_last}, retries_limit={self._retries_left}, waiting for ACK")
    repeat_count: '1000'
    repeat_enable: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      ARQ_HEADER_SIZE = 4  # [SEQ][FLAGS][SRC_ID][DST_ID]


      class blk(gr.basic_block):
          """
          Frame classifier for ARQ frames.

          Input (message port 'in'):
              PDU (meta, u8vector) representing one ARQ frame:
                byte 0 : SEQ
                byte 1 : FLAGS   (bit0 = LAST_FRAME, bit1 = IS_ACK)
                byte 2 : SRC_ID
                byte 3 : DST_ID
                byte 4.. : payload (zero-padded)

          Outputs:
              'ack_out' : PDU forwarded if frame is an ACK (IS_ACK = 1)
              'msg_out' : PDU forwarded if frame is DATA  (IS_ACK = 0)

          The payload is not modified; the whole frame is passed through.
          """

          def __init__(self, label="frame_classifier"):
              gr.basic_block.__init__(
                  self,
                  name="frame_classifier",
                  in_sig=None,
                  out_sig=None,
              )

              self.label = str(label)

              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("ack_out"))
              self.message_port_register_out(pmt.intern("msg_out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_pdu)

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)

              if not pmt.is_u8vector(vec):
                  print(f"[{self.label}] ERROR: payload is not u8vector")
                  return

              data = bytes(pmt.u8vector_elements(vec))
              n    = len(data)

              if n < ARQ_HEADER_SIZE:
                  print(f"[{self.label}] ERROR: frame too short ({n} bytes)")
                  return

              seq   = data[0]
              flags = data[1]
              src   = data[2]
              dst   = data[3]

              is_last = (flags >> 0) & 0x01
              is_ack  = (flags >> 1) & 0x01

              # Optional debug
              print(f"[{self.label}] frame len={n}, SEQ={seq}, "
                    f"FLAGS=0x{flags:02X} (last={is_last}, ack={is_ack}), "
                    f"SRC={src}, DST={dst}")

              if is_ack:
                  # ACK frame → send to ack_out (for arq_framer.ack_in path)
                  self.message_port_pub(pmt.intern("ack_out"), pdu)
              else:
                  # DATA frame → send to msg_out (for message_reassembler path)
                  self.message_port_pub(pmt.intern("msg_out"), pdu)
    label: '"frame_classifier"'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      ARQ_FRAME_SIZE   = 48
      ARQ_HEADER_SIZE  = 4  # [SEQ][FLAGS][SRC][DST]


      class blk(gr.basic_block):
          """
          Message reassembler for stop-and-wait ARQ frames with duplicate filtering.

          Input (message port 'in'):
              - DATA ARQ frames as PDUs:
                [SEQ][FLAGS][SRC][DST][payload (0-padded)]

          Internal behavior:
              - Appends payload bytes from each DATA frame (starting at byte 4)
                into an internal buffer.
              - When a frame with LAST_FRAME=1 arrives:
                  * interpret buffer as:
                      [src_id][dst_id][len_hi][len_lo][payload...][padding...]
                  * compute total message length = 4 + msg_len
                  * trim padding
                  * compare with last delivered message:
                      - if identical -> drop (duplicate)
                      - if different -> emit to 'msg_out' and remember it
                  * clear buffer for the next message.
          """

          def __init__(self, label="message_reassembler"):
              gr.basic_block.__init__(
                  self,
                  name="message_reassembler",
                  in_sig=None,
                  out_sig=None,
              )

              self.label = str(label)

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("msg_out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_pdu)

              # Buffer for assembling one complete message
              self._buf = bytearray()
              self._assembling = False

              # Last delivered full message bytes (for duplicate suppression)
              self._last_msg_bytes = None

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)

              if not pmt.is_u8vector(vec):
                  print(f"[{self.label}] ERROR: payload is not u8vector")
                  return

              frame = bytes(pmt.u8vector_elements(vec))
              n     = len(frame)

              if n < ARQ_HEADER_SIZE:
                  print(f"[{self.label}] ERROR: ARQ frame too short ({n} bytes)")
                  return

              seq   = frame[0]
              flags = frame[1]
              src   = frame[2]
              dst   = frame[3]

              is_last = (flags >> 0) & 0x01
              is_ack  = (flags >> 1) & 0x01

              if is_ack:
                  # Should not see ACKs here if wired correctly
                  print(f"[{self.label}] WARNING: received ACK frame on reassembler, ignoring")
                  return

              # Payload chunk (with zero padding)
              payload_chunk = frame[ARQ_HEADER_SIZE:]

              # Start of a new message?
              if not self._assembling:
                  self._buf = bytearray()
                  self._assembling = True
                  print(f"[{self.label}] Starting new message assembly "
                        f"(SEQ={seq}, SRC={src}, DST={dst})")

              # Append chunk
              self._buf.extend(payload_chunk)

              # If not last frame, just wait for more
              if not is_last:
                  print(f"[{self.label}] Appended chunk (len={len(payload_chunk)}), "
                        f"buffered={len(self._buf)} bytes, waiting for more frames")
                  return

              # Last frame: reconstruct full message and emit (or drop as duplicate)
              print(f"[{self.label}] Last frame received (SEQ={seq}), "
                    f"total buffered={len(self._buf)} bytes")

              full_msg = bytes(self._buf)

              if len(full_msg) < 4:
                  print(f"[{self.label}] ERROR: assembled message too short "
                        f"({len(full_msg)} bytes)")
                  self._buf = bytearray()
                  self._assembling = False
                  return

              # Parse original message header:
              # [src_id][dst_id][len_hi][len_lo][payload...]
              src_id = full_msg[0]
              dst_id = full_msg[1]
              msg_len = (full_msg[2] << 8) | full_msg[3]

              total_needed = 4 + msg_len

              if total_needed > len(full_msg):
                  print(f"[{self.label}] WARNING: needed {total_needed} bytes, "
                        f"but only {len(full_msg)} available; truncating")
                  total_needed = len(full_msg)

              msg_bytes = full_msg[:total_needed]

              # ---------- DUPLICATE SUPPRESSION ----------
              if self._last_msg_bytes is not None and msg_bytes == self._last_msg_bytes:
                  print(f"[{self.label}] Duplicate complete message detected; "
                        f"dropping (src={src_id}, dst={dst_id}, len={msg_len})")
              else:
                  # Build output PDU for ZMQ PUB (or any upper layer)
                  out_meta = pmt.make_dict()  # or propagate some fields if you like
                  out_vec  = pmt.init_u8vector(len(msg_bytes), list(msg_bytes))
                  out_pdu  = pmt.cons(out_meta, out_vec)

                  self.message_port_pub(pmt.intern("msg_out"), out_pdu)

                  print(f"[{self.label}] Emitted reassembled message: "
                        f"src={src_id}, dst={dst_id}, len={msg_len}")

                  # Remember this message as the last delivered one
                  self._last_msg_bytes = msg_bytes
              # -------------------------------------------

              # Reset for next message
              self._buf = bytearray()
              self._assembling = False
    label: '"message_reassembler"'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      ARQ_FRAME_SIZE   = 48
      ARQ_HEADER_SIZE  = 4  # [SEQ][FLAGS][SRC][DST]


      class blk(gr.basic_block):
          """
          ACK generator for ARQ frames.

          Input (message port 'in'):
              - PDU (meta, u8vector) representing one DATA ARQ frame:
                [SEQ][FLAGS][SRC][DST][payload...]

          Output (message port 'out'):
              - PDU(s) that are ACK ARQ frames, ready to be sent through
                CRC Append → Protocol Formatter → radio.

          ACK frame format (48B):
              byte 0 : SEQ       (copied from DATA frame)
              byte 1 : FLAGS     (LAST=1, IS_ACK=1 => 0x03)
              byte 2 : SRC_ID    (original DST_ID)
              byte 3 : DST_ID    (original SRC_ID)
              byte 4..47 : zeros

          Parameters:
              repeat_enable (bool) : if True, send ACK repeat_count times
              repeat_count  (int)  : number of repeats when enabled
          """

          def __init__(self, repeat_enable=False, repeat_count=1,
                       label="ack_generator"):
              gr.basic_block.__init__(
                  self,
                  name="ack_generator",
                  in_sig=None,
                  out_sig=None,
              )

              self.label = str(label)

              self.repeat_enable = bool(repeat_enable)
              self.repeat_count  = max(1, int(repeat_count))

              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(pmt.intern("in"), self.handle_pdu)

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)

              if not pmt.is_u8vector(vec):
                  print(f"[{self.label}] ERROR: payload is not u8vector")
                  return

              data = bytes(pmt.u8vector_elements(vec))
              n    = len(data)

              if n < ARQ_HEADER_SIZE:
                  print(f"[{self.label}] ERROR: frame too short ({n} bytes)")
                  return

              seq   = data[0]
              flags = data[1]
              src   = data[2]
              dst   = data[3]

              is_ack = (flags >> 1) & 0x01
              if is_ack:
                  # Defensive: we shouldn't be fed ACKs on this path
                  print(f"[{self.label}] WARNING: got ACK frame on ack_generator input, ignoring")
                  return

              # --- Build ACK frame ---
              ack_seq  = seq
              last_bit = 1  # mark ACK as "last" for convenience
              is_ack   = 1
              ack_flags = (last_bit << 0) | (is_ack << 1)  # 0b0011 = 0x03

              ack_src = dst  # swap src/dst
              ack_dst = src

              frame = bytearray(ARQ_FRAME_SIZE)
              frame[0] = ack_seq & 0xFF
              frame[1] = ack_flags & 0xFF
              frame[2] = ack_src & 0xFF
              frame[3] = ack_dst & 0xFF
              # bytes 4..47 remain zeros

              ack_bytes = bytes(frame)

              # Metadata for ACK — you can keep it empty or copy selected fields
              ack_meta = pmt.make_dict()
              ack_vec  = pmt.init_u8vector(len(ack_bytes), list(ack_bytes))
              ack_pdu  = pmt.cons(ack_meta, ack_vec)

              repeats = self.repeat_count if self.repeat_enable else 1

              print(f"[{self.label}] Generated ACK for SEQ={ack_seq}, "
                    f"SRC={ack_src}, DST={ack_dst}, repeats={repeats}")

              for _ in range(repeats):
                  self.message_port_pub(pmt.intern("out"), ack_pdu)
    label: '"ack_generator"'
    repeat_count: '4'
    repeat_enable: 'True'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Simple PDU multiplexer:
            - Input ports: 'data_in', 'ack_in'
            - Output port: 'out'
          For any PDU arriving on either input, it forwards it to 'out'.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_mux",
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_in(pmt.intern("data_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              self.set_msg_handler(pmt.intern("data_in"), self._handle_pdu)
              self.set_msg_handler(pmt.intern("ack_in"), self._handle_pdu)

              self.message_port_register_out(pmt.intern("out"))

          def _handle_pdu(self, pdu):
              # Just forward any PDU to the output
              self.message_port_pub(pmt.intern("out"), pdu)
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,0,10,10
    legend: 'False'
    name: Synced & Equalized Constellation
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: '3000000000'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1.5e6
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ACK_OUT
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decodedSignal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: ACK_IN
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: transmitStream
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: rxIN
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: decodedBits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: decodedSignal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ACK_OUT
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK_IN
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: transmitStream
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: rxIN
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: decodedBits
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://*:5555
    bind: 'True'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_2_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_2, '0']
- [blocks_throttle2_0_0, '0', epy_block_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0_0, '0', channels_channel_model_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, epy_block_5, data_in]
- [digital_crc_append_0_0, out, epy_block_5, ack_in]
- [digital_crc_check_0, ok, epy_block_2, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, msg_out, epy_block_1, data_in]
- [epy_block_1, frame_out, digital_crc_append_0, in]
- [epy_block_2, ack_out, virtual_sink_1_0, '0']
- [epy_block_2, msg_out, epy_block_3, in]
- [epy_block_2, msg_out, epy_block_4, in]
- [epy_block_3, msg_out, zeromq_pub_msg_sink_0, in]
- [epy_block_4, out, blocks_message_debug_0, print]
- [epy_block_4, out, virtual_sink_0, '0']
- [epy_block_5, out, digital_protocol_formatter_async_0, in]
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [soapy_bladerf_source_0, '0', fft_filter_xxx_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_1_0, '0', digital_crc_append_0_0, in]
- [virtual_source_2, '0', epy_block_1, ack_in]
- [virtual_source_3, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_3_0, '0', fft_filter_xxx_0, '0']
- [virtual_source_3_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
